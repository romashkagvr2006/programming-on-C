# Keil uVision project ARM_OS.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC2294 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: ARM_OS +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STDIO
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x81000000 size 0x7ffff
  memory RVCT9: RAM 0x40000000 size 0x4000
  group ARM_OS
    ./: ARM_OS.c Startup.s
  group APP
    ./APP/: DM9000_16.c Serial.c STD_Files.c Retarget.c Command.c
  group TCP
    ./TCP/: HTTP_uif.c Net_Config.c HTTP_CGI.c
  group LIB
    ../../../RV31/LIB/: TCP_ARM_L.lib
  group WEB
    ./WEB/: web.inp WEB.C
  group FS
    ./FS/: File_Config.c
    ../../../RV31/LIB/: FS_ARM_L.lib
  group RSS
    ./RSS/: RSS.c SPI_LPC2294.c zapros.c meteo.c
